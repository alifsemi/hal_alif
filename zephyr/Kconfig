## zephyr/Kconfig
```kconfig
rsource "../se_services/zephyr/Kconfig"
rsource "../drivers/isp/Kconfig"
rsource "../drivers/jpeg/Kconfig"
```
